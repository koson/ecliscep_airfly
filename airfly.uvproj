# Keil uVision project airfly.uvproj, settings and files
target STM32F103RB (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: airfly +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: CORE;HARDWARE/LED;STM32F10x_FWLib/inc;SYSTEM/delay;SYSTEM/sys;SYSTEM/usart;USER;UCOSII/CONFIG;UCOSII/CORE;UCOSII/PORT;Driver;D:/Keil/ARM/ARMCC/include;D:/Keil/ARM/INC/ST/STM32F10x
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_md_arm.s
  group Driver
    ./Driver/: drv_pwm.c
  group HARDWARE_LED
    ./HARDWARE/LED/: led.c
  group STM32F10x_FWLib_src
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM_delay
    ./SYSTEM/delay/: delay.c
  group SYSTEM_sys
    ./SYSTEM/sys/: sys.c
  group SYSTEM_usart
    ./SYSTEM/usart/: usart.c
  group UCOSII_CORE
    ./UCOSII/CORE/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C
  group UCOSII_PORT
    ./UCOSII/PORT/: os_cpu_c.c
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
